# Keil uVision project Printf.uvprojx, settings and files
target N32H473 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H487ZE Nationstech
  pack: Nationstech.N32H48x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Printf +hex
  AfterMake: fromelf --bin --output=.\bin\Printf.bin .\Objects\Printf.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H473, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\n32h47x_48x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group STARTUP
    ../../firmware/CMSIS/device/startup/: startup_n32h473.s startup_n32h474.s startup_n32h475.s startup_n32h482.s startup_n32h487.s
  group CMSIS
    ../../firmware/CMSIS/device/: system_n32h47x_48x.c
  group FWLB
    ../../firmware/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_rcc.c n32h47x_48x_flash.c n32h47x_48x_usart.c n32h47x_48x_gpio.c n32h47x_48x_dma.c n32h47x_48x_exti.c n32h47x_48x_spi.c
  group USER
    ../src/: main.c n32h47x_48x_it.c uart.c uart.h fifo.c fifo.h xprintf.c xprintf.h shell.c shell.h shell_func.c shell_func.h flash.c flash.h flash_itf.c flash_itf.h spi.c spi.h xmodem.c xmodem.h kiss_fft_port.c kiss_fft_port.h kissfft_test.c kissfft_test.h
  group DOC
    ../: readme.txt
  group fatfs
    ../src/ff15a/source/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
  group kissfft
    ../src/kissfft/: kiss_fftr.h kiss_fftr.c kiss_fftndr.h kiss_fftndr.c kiss_fftnd.h kiss_fftnd.c kiss_fft_log.h kiss_fft.h kiss_fft.c kfc.h kfc.c _kiss_fft_guts.h
  group speex
    ../src/speexdsp/libspeexdsp/: _kiss_fft_guts.h arch.h bfin.h buffer.c fftwrap.c fftwrap.h filterbank.c filterbank.h fixed_arm4.h fixed_arm5e.h fixed_bfin.h fixed_debug.h fixed_generic.h jitter.c kiss_fft.c kiss_fft.h kiss_fftr.c kiss_fftr.h math_approx.h mdf.c misc_bfin.h os_support.h preprocess.c pseudofloat.h resample.c resample_neon.h resample_sse.h scal.c smallft.c smallft.h vorbis_psy.h
    ../src/: speexecho.c
    ../src/speexdsp/: os_support_custom.c
target N32H474 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H487ZE Nationstech
  pack: Nationstech.N32H48x_DFP.1.0.0
  cpu: as above
  output: Printf +hex
  AfterMake: fromelf --bin --output=.\bin\Printf.bin .\Objects\Printf.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H474, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
target N32H475 (6220000::V6.22::ARMCLANG)
  device: N32H487ZE Nationstech
  pack: Nationstech.N32H48x_DFP.1.0.0
  cpu: as above
  output: Printf +hex
  AfterMake: fromelf --bin --output=.\bin\Printf.bin .\Objects\Printf.axf
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: N32H487,USE_STDPERIPH_DRIVER,HAVE_CONFIG_H
  c include: ..\..\firmware\CMSIS\core;..\..\firmware\CMSIS\device;..\inc;..\..\firmware\n32h47x_48x_std_periph_driver\inc;..\src;..\src\ff15a\source;..\src\kissfft;..\src\speexdsp\include;..\src\speexdsp\libspeexdsp;..\src\speexdsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
target N32H482 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H482ZE Nationstech
  pack: Nationstech.N32H48x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x31000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Printf +hex
  AfterMake: fromelf --bin --output=.\bin\Printf.bin .\Objects\Printf.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H482, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x31000
target N32H487 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H487ZE Nationstech
  pack: Nationstech.N32H48x_DFP.1.0.0
  cpu: as above
  output: Printf +hex
  AfterMake: fromelf --bin --output=.\bin\Printf.bin .\Objects\Printf.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H487, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x31000
